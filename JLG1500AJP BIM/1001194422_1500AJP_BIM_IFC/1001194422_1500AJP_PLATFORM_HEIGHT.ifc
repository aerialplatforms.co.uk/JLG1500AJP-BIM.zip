Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-05-03T10:14:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 03 10:14:55 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{AD6F4A54-D4C1-403E-A18E-E6FE79EB6AD8}\ifc * Database version: 5507 * Database creation date: Thu May 03 10:14:42 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 03 10:14:42 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 03 10:14:42 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 m
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 m; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 m

# IfcTransportElement: Height=46.15m(151'-5")_Reach=5.91m(19'-5"), 1001194422_1500AJP:Height=46.15m(151'-5")_Reach=5.91m(19'-5"):5929227
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Plastic_Blue, JLG_Plastic_Green, JLG_Paint_Black, JLG_Plastic_Yellow, JLG_Steel, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_White, JLG_Paint_Orange, JLG_Paint_Beige, JLG_Paint_Silver Grey, JLG_Rubber_Black, JLG_Plastic_Red
Type - Constraints - Aa: 68 deg; AEa: 75 deg; E: 4.925 m; E1: 7.645 m; Ja: 75 deg; Jib Rotation: 0 deg; P270: yes; P450: yes; Reach: 148
Type - Data - Auxiliary Power: 12V DC; Axle Oscillation: 0.3 m (1 ft 0 in); Diesel Engine: Deutz T4F 3.6L, 100 bhp; Drive Speed: 4.5 kph (2.8 mph); Fuel Tank Capacity: 170L (45 gal); Gradeability 4WD: 40%; Horizontal Outreach (restricted): 20.42 m (67 ft 0 in); Horizontal Outreach (un restricted): 22.86 m (75 ft 0 in); Hydraulic Tank Capacity: 352L (93 gal); Jib – Overall Length: 2.44 m (8 ft 0 in); Jib Range of Articulation: 130 Degrees (+75°/ -55°); Machine weight (ANSI): 26,027kg (57,380 lbs); Machine weight (CE): 26,027kg (57,380 lbs); Max Ground Bearing Pressure (ANSI): 8.61kg/cm2 (122.5 psi); Max Ground Bearing Pressure (CE): 8.61kg/cm2 (122.5 psi); Model Name: 1500AJP; Platform Capacity restricted (ANSI): 450 Kg (992 lbs); Platform Capacity restricted (CE): 450 Kg (992 lbs); Platform Capacity Unrestricted (ANSI): 270 Kg (595 lbs); Platform Capacity Unrestricted (CE): 270 Kg (595 lbs); Platform Height (restricted): 46.15 m (151 ft 5 in); Platform Height (un restricted): 46.15 m (151 ft 5 in); Platform Rotator (Hydraulic): 125 Degrees; Platform Size: 0.91 m x 2.44 m (3 ft 0 in x 8 ft 0 in); Swing: 360 degree Continuous; Turning Radius – Inside (Axles Extended): 2.3 m (7 ft 6.25 in); Turning Radius – Inside (Axles Retracted): 7.10 m(23 ft 3.75 in); Turning Radius – Outside (Axles Extended): 6.6 m (21 ft 7.5 in); Turning Radius – Outside (Axles Retracted): 9.5 m (31 ft 2.25 in); Tyres: 1179x427x711 foam filled or 445/50 D710 24 ply foam filled
Type - Dimensions - Aa1: 248 deg; AEa1: 255 deg; Ha: 68 deg; Ha1: 248 deg; Ja1: 255 deg; JHa: -75 deg; JHa1: 105 deg; PHa: -75 deg; PHa1: 105 deg
Type - General - Articulating Jib: 2.44 m (8 ft 0 in) articulating jib; Hydraulic Platform Rotator: 125 Degrees; Platform Side Entry: 0.91 m x 2.44 m (3 ft 0 in x 8 ft 0 in); Tilt Alarm/Indicator Light: 5 degree tilt alarm and indicator light
Type - Identity Data - Model: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Height=46.15m(151'-5")_Reach=5.91m(19'-5")
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001194422_1500AJP; NBSDescription: Ultra Series Boom Lifts; NBSNote: n/a; NBSObjectName: JLG 1500AJP_Ultra Series Boom Lifts; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: n/a; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001194422_1500AJP; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 1500AJP; ModelReference: JLG - Ultra Series Boom Lifts; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Ultra Series Boom Lifts; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 m; P2: no; P4: no
Dimensions - Area: 2148 m2; Leg Rotation: 0 deg; Platform Rotation: 0 deg; PR: 0 deg; Reach Diagram: no; Sa: 180 deg; Swing_Angle: 0 deg; Turning radius_Extended: no; Turning radius_Retracted: no; Volume: 14.6269 m3; Working Area: no
Identity Data - Mark: 129
Other - Family: 1001194422_1500AJP: Height=46.15m(151'-5")_Reach=5.91m(19'-5"); Family and Type: 1001194422_1500AJP: Height=46.15m(151'-5")_Reach=5.91m(19'-5"); Type: 1001194422_1500AJP: Height=46.15m(151'-5")_Reach=5.91m(19'-5"); Type Id: 1001194422_1500AJP: Height=46.15m(151'-5")_Reach=5.91m(19'-5"); WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: New Construction
